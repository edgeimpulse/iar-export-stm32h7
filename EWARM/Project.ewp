# IAR project Project.ewp, settings and files
configuration STM32H747I_DISCO_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_M7 ST STM32H747XI_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM7
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\STM32CubeH7\Drivers\CMSIS\Include; ..\STM32CubeH7\Drivers\CMSIS\Device\ST\STM32H7xx\Include; C:\Users\Arjan\iar-export-stm32h7\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc; ..\STM32CubeH7\Drivers\BSP\STM32H747I-DISCO; ..\STM32CubeH7\Drivers\BSP\Components\Common; ..\STM32CubeH7\Utilities\lcd; ..\STM32CubeH7\Utilities\Fonts; ..\STM32CubeH7\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32H747I_EVAL_CM7.hex
  ILINK.IlinkOutputFile: STM32H747I_EVAL_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H747I_DISCO_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H747XI_M4 ST STM32H747XI_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_DISCO; CORE_CM4
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM4\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H747I-DISCO; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H747I_EVAL_CM4.hex
  ILINK.IlinkOutputFile: STM32H747I_EVAL_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Doc
    ../: Readme.md
  group Drivers/BSP/STM32H747I_DISCO
    ../STM32CubeH7/Drivers/BSP/STM32H747I-DISCO/: stm32h747i_discovery.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32h747xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
